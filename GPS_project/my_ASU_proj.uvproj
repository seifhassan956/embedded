# Keil uVision project my_ASU_proj.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: my_ASU_proj
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group MCAL
    ./MCAL/GPIO_DRIVER/: GPIO.c GPIO_INT.h
    ./MCAL/UART_DRIVER/: UART_Program.c UART_Interface.h
    ./MCAL/SYSTICK_DRIVER/: SYSTICK_HEADER.h SYSTICK_MAIN.c
  group SERVICES
    ./SERVICES/: tm4c123gh6pm.h BITMATH.h
  group APP
    ./application/: main.c startup_TM4C123.s
  group HAL
    ./HAL/GPS_INTERFACE/: GPS_MAIN.c GPS_HEADER.h
    ./HAL/LED_DRIVER/: LED_INT.h LED_MAIN.c
    ./HAL/LCD_DRIVER/: LCD_HEADER.h LCD_CONFIG.h LCD_HELPER.h LCD_MAIN.c
